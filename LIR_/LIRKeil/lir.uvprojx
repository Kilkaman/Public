# Keil uVision project lir.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lir +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ./inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Source Group 1
    ./src/: startup_MDR32F9Qx.s main.c timer.c uart.c ssp.c
